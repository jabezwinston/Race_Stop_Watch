# Keil uVision project Race_stop_watch.uvproj, settings and files
target default (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: Race_stop_watch +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: main.c
